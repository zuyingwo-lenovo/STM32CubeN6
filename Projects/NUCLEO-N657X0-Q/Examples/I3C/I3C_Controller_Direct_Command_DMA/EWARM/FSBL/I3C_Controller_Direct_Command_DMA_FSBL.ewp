# IAR project I3C_Controller_Direct_Command_DMA_FSBL.ewp, settings and files
configuration I3C_Controller_Direct_Command_DMA_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 0
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx
  ICCARM.CCIncludePath2: ../../FSBL/Inc; ../../../../../../../Drivers/BSP/STM32N6xx_Nucleo; C:/Users/ANDY-TP-001/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0/Drivers/STM32N6xx_HAL_Driver/Inc; C:/Users/ANDY-TP-001/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0/Drivers/CMSIS/Device/ST/STM32N6xx/Include; C:/Users/ANDY-TP-001/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0/Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; C:/Users/ANDY-TP-001/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I3C_Controller_Direct_Command_DMA_FSBL.bin
  ILINK.IlinkOutputFile: I3C_Controller_Direct_Command_DMA_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL
    ../../FSBL/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/BSP/STM32N6xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c
  group Drivers/STM32N6xx_HAL_Driver
    C:/Users/ANDY-TP-001/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_i3c.c stm32n6xx_util_i3c.c stm32n6xx_hal_rif.c
